# Keil uVision project master.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8003 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(16000000)
  output: master
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\赛元8003应用资料\SC92F8003 DEMO CODE\SC92F8003_Lib\inc
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./: main.c onewire.c onewire.h
  group src
    ../赛元8003应用资料/SC92F8003 DEMO CODE/SC92F8003_Lib/src/: sc92f8003_gpio.c
